## Kconfig
```kconfig
#
# Input core configuration
#



config AML_GPIO_KEY
	tristate "Amlogic gpio key device surport"
	default y
	help
	  Say Y here if you want to use the amlogic hold key.
```
